Commit message: Updating for pulling from Desktop

File: urdf/panda_stick.urdf (robot description, URDF)
Before this commit: robot panda, 14 links, 13 joints
Links:
- link stick_link: geometry collision box size=0.30000 0.01000 0.050000; visual box size=0.30000 0.01000 0.05000
